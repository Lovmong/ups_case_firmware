# Keil uVision project ups_case_firmware.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: ups_case_firmware_v0.0.1. +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\system
  group system
    ./system/: STARTUP.A51
  group src
    ./src/: main.c btn.c delay.c eeprom.c fan.c power.c rgb.c uart.c
